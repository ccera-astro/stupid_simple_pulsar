<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>stupid_simple_pulsar</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbrate</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbsize</value></param>
<param><key>value</key><value>fbtable[int(round(samp_rate/1.0e6))]*res</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbtable</value></param>
<param><key>comment</key><value>Table of sample-rate vs number of
filterbank bins

OK at 400 to 600Mhz or so, but
probably too many filterbank bins
 at higher frequencies</value></param>
<param><key>value</key><value>[2,2,4,4,8,8,8,8,16,16,16,16,32,32,32,32,32,32,64,64,64,64]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>flower</value></param>
<param><key>value</key><value>(freq-(samp_rate/2.0))/1.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fupper</value></param>
<param><key>value</key><value>(freq+(samp_rate/2.0))/1.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(srate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>smear</value></param>
<param><key>value</key><value>dm/2.41e-4 * (1.0/(flower*flower)-1.0/(fupper*fupper))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tbins</value></param>
<param><key>comment</key><value>Try to compute an optimal number of
time bins.  We increase this by 25% just
to get a little bit of extra resolution in trade for
a tiny penalty in SNR.</value></param>
<param><key>value</key><value>int((period/width)*1.25)</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Stupid_folder</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import time
import json

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """A pulsar folder/de-dispersion block"""

    def __init__(self, fbsize=16,smear=10.0,period=0.714,filename='/dev/null',fbrate=2500,tbins=250,interval=30,tppms="0.0"):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Stupid Pulsar Folder',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        
        self.set_output_multiple(fbsize)
        self.delaymap = [0]*fbsize
        delayincr = smear * float(fbrate)
        delayincr /= float(fbsize)
        delayincr = round(delayincr)
        delayincr = int(delayincr)
        for i in range(fbsize):
            self.delaymap[(fbsize-i)-1] = i*delayincr
        
        #
        # Needed in a few places
        #
        self.flen = fbsize
        
        #
        # The pulsar period
        #
        self.p0 = period
        
        #
        # The derived single-period pulse profile with various shifts
        #
        # We take it as a string, because that's easiest for command-line origin
        #
        if (isinstance(tppms,str)):
            trials = tppms.split(",")
            self.shifts = []
            for p in trials:
                self.shifts.append(float(p)*1.0e-6)
        elif (isinstance(tppms,list)):
            self.shifts = []
            for p in tppms:
                self.shifts.append(float(p)*1.0e-6)
        elif (isinstance(tppms,float) or isinstance(tppms,int)):
            self.shifts = [float(tppms)*1.0e-6]
        #
        # Create numpy 2D arrays for profile accumulator and counter
        #
        self.profiles = np.zeros((len(self.shifts),tbins))
        self.pcounts = np.zeros((len(self.shifts),tbins))
        self.nprofiles = len(self.profiles)
        
        #
        #
        # How much time is in each bin?
        # The profile should be "exactly" as long as a single
        #   pulse period
        #
        self.tbint = []
        for shift in self.shifts:
            self.tbint.append((self.p0*(1.0+shift))/float(tbins))
        
        
        #
        # The profile length
        #   
        self.plen = tbins
        
        #
        # Sample period
        #
        self.sper = 1.0/fbrate
        
        #
        # Mission Elapsed Time
        # This is moved along at every time samples arrival--incremented
        #   by 'self.sper'
        #
        self.MET = 0.0
        
        #
        # Open the output file
        #
        self.fname = filename
        self.sequence = 0
        
        self.max_in = 0.0
        self.min_in = 100000000
        
        #
        # The logging interval
        #
        self.INTERVAL = fbrate*interval
        self.logcount = self.INTERVAL
        
        #print "tbin %-11.7f tbinp %-11.7f tbinn %-11.7f" % (self.tbin, self.tbinp, self.tbinn)
        fp = open(self.fname, "w")
        fp.write ("[\n")
        fp.close()
        
    def work(self, input_items, output_items):
        """Do dedispersion/folding"""
        q = input_items[0]
        l = len(q)
        if (l &gt; self.max_in):
            self.max_in = l
        elif (l &lt; self.min_in):
            self.min_in = l
        for i in range(l/self.flen):
            #
            # Do delay/dedispersion logic
            #
            if (self.delaymap[0] &gt; 0):
                outval = 0.0
                for j in range(self.flen):
                    if (self.delaymap[j] == 0):
                        outval += q[(i*self.flen)+j]
                #
                # Decrement delay counters
                #
                for j in range(self.flen):
                    if (self.delaymap[j] &gt; 0):
                        self.delaymap[j] -= 1
                    else:
                        break
            else:
                outval = sum(q[(i*self.flen):(i*self.flen)+self.flen])
            
            #
            # Figure out where this sample goes in the profile buffer, based on MET
            # We place the next sample based on the MET, re-expressed in terms of
            #   total time-bins (self.tbint) modulo the profile length
            #
            # Update all the profiles
            #
            for x in range(self.nprofiles):
                where = self.MET/self.tbint[x]
                where = int(where) % self.plen
                self.profiles[x][where] += outval
                self.pcounts[x][where] += 1
            #
            # Increment Mission Elapsed Time
            #
            self.MET += self.sper
            
            #
            # Decrement the log counter
            #
            self.logcount -= 1
            
            #
            # If time to log, the output is the reduced-by-counts
            #  value of the profile.
            #
            if (self.logcount &lt;= 0):
                fp = open(self.fname, "a")
                outputs = []
                for x in range(self.nprofiles):
                    outputs.append(np.divide(self.profiles[x],self.pcounts[x]))
                d = {}
                t = time.gmtime()
                d["time"] = "%04d%02d%02d-%02d:%02d:%02d" % (t.tm_year,
                    t.tm_mon, t.tm_mday, t.tm_hour, t.tm_min, t.tm_sec)
                d["sequence"] = self.sequence
                d["max_input_length"] = self.max_in
                d["min_input_length"] = self.min_in
                self.sequence += 1
                profiles = []
                for x in range(self.nprofiles):
                    pd = {}
                    pd["profile"] = list(outputs[x])
                    pd["p0"] = self.p0*(1.0+self.shifts[x])
                    pd["shift"] = self.shifts[x]
                    profiles.append(pd)
                d["profiles"] = profiles
                fp.write(json.dumps(d, indent=4, sort_keys=True)+",\n")
                fp.close()
                self.logcount = self.INTERVAL
            
            
        return len(q)
</value></param>
<param><key>comment</key><value>Produce the folded output estimates
Generates a mostly-valid
JSON file
Estimates are produced for multiple
offsets from nominal pulse rate</value></param>
<param><key>fbrate</key><value>fbrate</value></param>
<param><key>fbsize</key><value>fbsize</value></param>
<param><key>filename</key><value>outfile</value></param>
<param><key>interval</key><value>logtime</value></param>
<param><key>period</key><value>period</value></param>
<param><key>smear</key><value>smear</value></param>
<param><key>tbins</key><value>tbins</value></param>
<param><key>tppms</key><value>[-150,-100,-50,-20,-10,0,10,20,50,100,150]</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>comment</key><value>Frequency inversion</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>comment</key><value>Limit runtime</value></param>
<param><key>num_items</key><value>samp_rate*obstime</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>comment</key><value>Decimate down to output rate</value></param>
<param><key>n</key><value>samp_rate/fbsize/fbrate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>comment</key><value>Convert to stream
Folder will convert back to vector
internally</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Device String</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dm</value></param>
<param><key>label</key><value>Dispersion Measure</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>26.76</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>comment</key><value>FFT filterbank</value></param>
<param><key>fft_size</key><value>fbsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fbsize)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>408.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>logtime</value></param>
<param><key>label</key><value>Logging interval (seconds)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>obstime</value></param>
<param><key>label</key><value>Runtime in seconds</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>300</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>outfile</value></param>
<param><key>label</key><value>Output Filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>output.json</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>period</value></param>
<param><key>label</key><value>Pulsar period (seconds)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.714520</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>res</value></param>
<param><key>label</key><value>Filterbank resolution multiplier</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(samp_rate/fbsize/fbrate*0.5)</value></param>
<param><key>comment</key><value>Some light low-pass filtering</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.56e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>Pulsar W50 width (seconds)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0066</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>Stupid_folder</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
