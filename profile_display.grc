<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>profile_display</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pacer</value></param>
<param><key>block_id</key><value>a_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[1.0]*pbins</value></param>
<param><key>poll_rate</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pbins</value></param>
<param><key>value</key><value>int(period/width)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100e4</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>a_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>pbins</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>psr_display_helper.get_profile(pbins,pacer,port)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>pbins</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>pbins</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>foo_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>foo_0_0</value></param>
<param><key>import</key><value>import sys</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>period</value></param>
<param><key>label</key><value>Pulsar Period</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.714520</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pname</value></param>
<param><key>label</key><value>Pulsar Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"B0329+54"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>XMLRPC port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1420</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>psr_display_helper</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
try:
    import xmlrpclib as xmlrpc
except:
    import xmlrpc.client as xmlrpc

rpchandle = None
inited = False
def get_profile(nbins,pacer,port):
    global rpchandle
    global inited
    try:
        if (inited == False):
            rpchandle = xmlrpc.ServerProxy("http://localhost:%d" % port, allow_none=True)
        r = rpchandle.get_current_profile()
        inited = True
    except:
        return ([0.0]*nbins)
    return r
    
</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Pulsar Profile: %s" % pname</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>vlen</key><value>pbins</value></param>
<param><key>x_axis_label</key><value>"Pulsar Phase"</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0/pbins</value></param>
<param><key>x_units</key><value>"ph"</value></param>
<param><key>ymax</key><value>0.05</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>y_axis_label</key><value>"Amplitide"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>Pulsar width</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0066</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>a_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
